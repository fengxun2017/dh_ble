# Keil uVision project DH_BLE.uvprojx, settings and files
target DH_BLE_nrf51822 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: DH_BLE +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group device
    ../source/ChipDrv/NrfDrv/: arm_startup_nrf51.s system_nrf51.c
  group BleDrv
    ../source/BleDrv/: BleLPowerTimer.c BleHAccuracyTimer.c BleRadioDrv.c
  group NrfDrv
    ../source/ChipDrv/NrfDrv/: NrfClockDrv.c NrfRadioDrv.c NrfRtcDrv.c NrfTimer0Drv.c NrfUart.c
  group source
    ../source/: DhBleAux.c Main.c
  group debug
    ../source/debug/: rtt_log.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group BleStack
    ../source/BleStack/BleLink/: BleLinkAdvertising.c BleLink.c BleLinkConnect.c BleLinkControl.c
    ../source/BleStack/: BleAtt.c BleGatt.c BleL2cap.c DhBleEventNtf.c BleAdvertising.c BleGap.c
  group Common
    ../source/Common/: DhQueue.c DhBuffManage.c
  group CommDrv
    ../source/ChipDrv/CommDrv/: HardwareUart.c
