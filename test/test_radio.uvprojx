# Keil uVision project test_radio.uvprojx, settings and files
target nrf52840 (6180000::V6.18::ARMCLANG)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) IROM2(0x12000000,0x08000000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: DH_BLE_52840 +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: ..\debug_use_systemview\SEGGER;..\debug_use_systemview\Config
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
  group device
    ../source/ChipDrv/NrfDrv/nrf52840/: arm_startup_nrf52840.s system_nrf52840.c NrfClockDrv.c NrfRtcDrv.c NrfTimer0Drv.c NrfRadioDrv.c
  group systemview
    ../debug_use_systemview/SEGGER/: SEGGER_RTT.c SEGGER_SYSVIEW.c SEGGER_RTT_ASM_ARMv7M.S
    ../debug_use_systemview/Sample/NoOS/Config/Cortex-M/: SEGGER_SYSVIEW_Config_NoOS.c
  group main
    ./: test_radio.c
